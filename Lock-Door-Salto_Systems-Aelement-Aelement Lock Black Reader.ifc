Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
Time: 2017-06-27T21:05:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 2015.0.2014.0223 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 27 21:05:08 2017 * Host: RemoteThinktank * Database: C:\Users\User-PC\AppData\Local\Temp\{CDA408A3-5493-4BC6-B4C2-E13D9E1ED874}\ifc * Database version: 5507 * Database creation date: Tue Jun 27 21:05:08 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 27 21:05:08 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 27 21:05:08 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: D:\ifc\Lock-Door-Salto_Systems-Aelement.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Aelement Lock Black Reader, Lock-Door-Salto_Systems-Aelement:Aelement Lock Black Reader:4145
In: Level 1
Material: Double Layer Injection - Salto Systems - Black
Pset_BuildingElementProxyCommon - Reference: Aelement Lock Black Reader
Pset_ManufacturerTypeInformation - Manufacturer: Salto Systems
Constraints - Level: Level: Level 1; Offset: 0 mm; Work Plane: Level : Level 1
Construction - Include Mortise Lock: yes; Panel Thickness: 50.8 mm
Dimensions - Area: 0.0647511 m2; Volume: 0.00183256 m3; Depth: 52 mm; Height: 232 mm; Width: 130 mm
Identity Data - Accessory Part Number: LA1T17; Mark: 2; Part Description: AElement Design-Lock, Black Reader; Part Number: AExxxB; Copyright: Copyright © Salto Systems; Date Created: March 2, 2017; Date Modified: March 2, 2017; Description: AElement Design-Lock, Black Reader; Equipment Abbreviation: DH; Family Version: 1.0; Manufacturer: Salto Systems; Model: AExxxB; Model Disclaimer: Contact Salto Systems for more information; OmniClass Number: 23.30.40.11.34.14; OmniClass Title: Electrical Door Locking Control; Product Page URL: http://saltosystems.com/en/product-range/product/77/aelement-design-lock/; Type Name: Aelement Lock Black Reader; URL: http://www.saltosystems.com/
Other - Category: Security Devices; Family: Lock-Door-Salto_Systems-Aelement: Aelement Lock Black Reader; Family and Type: Lock-Door-Salto_Systems-Aelement: Aelement Lock Black Reader; Schedule Level: Level: Level 1; Type: Lock-Door-Salto_Systems-Aelement: Aelement Lock Black Reader; Type Id: Lock-Door-Salto_Systems-Aelement: Aelement Lock Black Reader; Family Name: Lock-Door-Salto_Systems-Aelement
Phasing - Phase Created: New Construction
Materials and Finishes - Product Material: Double Layer Injection - Salto Systems - Black
